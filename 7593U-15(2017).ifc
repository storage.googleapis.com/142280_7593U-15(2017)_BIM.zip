Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-02-25T08:48:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 25 08:48:23 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{7F4D3FAF-3AE3-4949-86F3-B0C8718109D2}\ifc * Database version: 5507 * Database creation date: Mon Feb 25 08:48:22 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 25 08:48:23 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 25 08:48:23 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7593U-15 Shower system, 6 V, 7593U-15(2017):7593U-15 Shower system, 6 V:360345
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 509 mm; FaucetNominalHeight: 1207.46 mm; FaucetNominalWidth: 370.5 mm; HandShowerNominalDepth: 103 mm; HandShowerNominalHeight: 377.49 mm; HandShowerNominalWidth: 123.5 mm; Projection: 137 mm
Type - Electrical(Type) - Battery: AA 1.5 V Lithium x 4; Bluetooth: 4.x; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7593U-15(2017); ConvergoRefNr: 0087-1902-0040-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Thermostatic rain shower faucet with easy-grip handles and a spout; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 21/02/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150083242; EMC Directive: 2014/30/EU; EN Standard: EN 1111, EN 15091; Noise Class: I (ISO 3822) Oras lab.; Protection Class: IP 55
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/7593U-15; Catalog Drawing URL: http://static.oras.com/catdrw/7593U-15; Class: Battery-operated, thermostatic, bluetooth; Dimension Drawing URL: http://static.oras.com/dimdrw/7593U-15; FDV Document URL: http://www.oras.com/datasheet/7593U-15/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7593U-15; Group: Shower faucets; Long Marketing: Thermostatic shower system with Wellfit body treatment, a spout, large overhead shower and a hand shower. Spacious shelf made of safety glass, Easy-to-use control handles and diverter. Temperature limiter in the handle. Oras Hydractiva Style hand shower with 3 spray modes: Sensitive (large & gently), Intense (powerful) and Pulse (massage), wall bracket included. Overhead shower size: 360 mm x 220 mm. The Wellfit body treatment can be individualized using the Oras App. The faucet is equipped with eccentric unions with silencer, litter filters and non-return valves.; Manufacturer: Oras; Market: INT;POL;RUS;EST;UKR; Model: 7593U-15 Shower system, 6 V; Name_en: 7593U-15 Shower system, 6 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 1017 x 230 x 144; Package Weight: 9.7 kg; Product Code: 7593U-15; Product Datasheet: http://www.oras.com/datasheet/7593U-15/en; Product Family: Oras Esteta WellFit; Product Image URL: http://static.oras.com/image/7593U-15; Product URL: http://static.oras.com/7593U-15; Type Name: 7593U-15 Shower system, 6 V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Safety glass; Connection: Ball eccentric union; Connection Size: G1/2; Diverter: Integrated diverter / Volume control; Flow Rate At 300kPa: 0.00847552 m3/s; Installation and Maintenance: http://static.oras.com/manual/7593U-15; Installation Type: Wall-mounted; Installation Width: CC150± 15 mm; Max. Hot Water Supply: 70 kg/K/s3; Pressure Loss With Flow 02ls: 300000 Pa; Shower Parts: Hand shower; Shower holder; Shower Hose (1750 mm); Shower head; Shower Spray: Intense; Sensitive; Shower Spray Number: 3spray; Spare Parts: http://static.oras.com/manual/7593U-15; Temperature: Thermostatic temperature control;Thermostatic safety stop at 38°C;THERMO COOL
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: 549; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7593U-15(2017); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7593U-15; Name: 7593U-15 Shower system, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 370x510x1210 mm / Hand shower: 125x105x380 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7593U-15; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7593U-15 Shower system, 6 V
Constraints - DistanceX-axis: 250 mm; DistanceY-axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 1.35127 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.23269 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7593U-15(2017): 7593U-15 Shower system, 6 V; Family and Type: 7593U-15(2017): 7593U-15 Shower system, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7593U-15(2017): 7593U-15 Shower system, 6 V; Type Id: 7593U-15(2017): 7593U-15 Shower system, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
